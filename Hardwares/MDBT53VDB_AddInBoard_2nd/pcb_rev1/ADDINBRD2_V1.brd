# Repository makmorit/SquareDevices

File README.md:

# Square devices

最終更新日：2025/3/5

## プログラム

- <b>[ファームウェア](Markdowns/nRF5340FW)</b><br>
Nordic社のSoC「nRF5340」搭載モジュール上で動作するアプリケーション・プログラムです。

- <b>[デスクトップツール](Markdowns/DesktopTools/README.md)</b><br>
PC環境から、nRF5340基板の動作に必要な各種設定／テスト等を行うためのツールです。<br>
[Windows版](Markdowns/DesktopTools/dotNET/README.md)と、[macOS版](Markdowns/DesktopTools/macOSApp/README.md)を用意しております。

## ハードウェア

- <b>[nRF5340基板の製作](Markdowns/Hardwares/README.md)</b><br>
Nordic社のSoC「nRF5340」搭載モジュールを使用したBLEデバイスを製作しています。

## EAGLE design Hardwares/MDBT53VDB_AddInBoard_2nd/pcb_rev1/ADDINBRD2_V1.brd

Parts:
CN2: IF_4PIN; HEADER_4PIN
CN3: IF_2PIN; HEADER_2PIN
D1, D2: PMEG4010AESBYL; DSN1006-2
F1: FCC16102ABTP; FCC16
Q1: DMP2035UFDF-7; U-DFN2020-6
Q2: BC817-40QA; DFN1010D-3
R1, R2: 5.1k; R0402N
R3: 51k; R0402N
SW1: SKRPACE010
U1: SN74AHC1G00DRLR; DRL0005A

Connections:
0V: CN2.1, CN3.1, D1.1 (A), Q2.2 (E), R3.1, SW1.1, SW1.2 (P1), U1.3 (GND); also elsewhere on the board
EXT_BAT: CN3.2, F1.1
unnamed: D1.2 (C), F1.2, Q1.4 (S), Q1.EXP2 (S), R1.2
unnamed: D2.1 (A), Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D), Q1.EXP (D)
unnamed: R2.1, U1.4 (Y)
unnamed: Q2.1 (B), R2.2, R3.2
NRST: CN2.3, U1.2 (B)
PWR_G: Q1.3 (G), Q2.3 (C), R1.1, SW1.3 (S), SW1.4 (S1)
PWR_OFF: CN2.4, U1.1 (A)
VIN: CN2.2, D2.2 (C), U1.5 (VCC); also elsewhere on the board

Notes on the sheet:
MDBT53V-DB Add-in board 2nd
Add-in board 2nd for MDBT53V-DB
動作電源投入・遮断回路
動作電源投入： タクトスイッチを約１秒間押し続けると VINに電源が供給されます。
動作電源遮断： PWR_OFFにHIGHを入力すると、 PWR_Gが閉塞され、VINに電源が 供給されなくなります。
外部接続用端子
動作電源： 乾電池などの電源を、 EXT_BATから供給します。
リセット同期： ボード側のNRST端子を、NRSTに接続します。 ボード側でリセット実行した場合でも、 動作電源をVINに供給し続けます。

Parts:
C1, C2: 1uF; C0402
C3: 0.1uF; C0402
CN1: IF_4PIN; HEADER_4PIN
CN4: IF_2PIN; HEADER_2PIN
R4: 5.1k; R0402N
R5: 15k; R0402N
U2: REF3325AIRSER; RSE0008A
U3: MCP6232T-E/MNY; TDFN-2X3

Connections:
0V: C1.2, C2.2, C3.2, CN1.1, R5.2, U2.4 (GND), U3.4 (VSS), U3.9 (VSS); also elsewhere on the board
AVBAT: CN1.3, U3.1 (VOUTA), U3.2 (VINA-)
AVBAT_IN: R4.2, R5.1, U3.3 (VINA+)
AVIN: C1.1, C3.1, CN1.4, CN4.1, R4.1, U2.5 (IN), U3.8 (VDD)
AVREF: CN1.2, U3.6 (VINB-), U3.7 (VOUTB)
AVREF_IN: C2.1, U2.8 (OUT), U3.5 (VINB+)
VIN: CN4.2; also elsewhere on the board

Notes on the sheet:
MDBT53V-DB Add-in board 2nd
Add-in board 2nd for MDBT53V-DB
電源電圧測定回路
電源電圧分圧
基準電圧生成（2.5V）
電圧入力バッファ
外部接続用端子
電源共有： 動作電源投入・遮断回路の VINをAVINとして利用します。
動作電源： 電源電圧測定回路の動作電源を AVINに供給します。
基準電圧出力： 動作電源電圧の変化にかかわらず、 常に2.5Vを出力します。
測定対象電圧出力： 動作電源電圧を約75%に分圧した 電圧を出力します。

Board: 2 copper layers, 25.0 x 31.0 mm, 21 parts (0 on the bottom side), 15 nets.

File Hardwares/MDBT53VDB_AddInBoard_2nd/pcb_rev1/bom/ADDINBRD2_V1_BOM.csv:

,,,,,,,,
,,,ADDINBRD2_V1 1PCS BOM  (Bill of Materials),,,,,
,,,,,,,,
,,,,,,,,
,,,,,,,,
Item #,*Ref Des,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package,Type,Your Instructions / Notes
1,"C1, C2",2,Taiyo Yuden,TMK105AC6105KV-F,MLCC - 25V 1uF X6S 10%,0402,SMD,
2,C3,1,Taiyo Yuden,UMK105B7104KV-FR,MLCC - 50V 0.1uF X7R 10%,0402,SMD,
3,"D1, D2",2,Nexperia,PMEG4010AESBYL,Schottky Diodes,DSN1006-2,SMD,
4,F1,1,Walsin,FCC16102ABTP,Surface Mount Fuse,0603,SMD,
5,Q1,1,Diodes Incorporated,DMP2035UFDF-7,P-channel enhancement mode MOSFET,U-DFN2020-6,SMD,
6,Q2,1,Nexperia,BC817-40QAZ,NPN general-purpose transistor,DFN-1010D-3,SMD,
7,"R1, R2",2,Vishay,CRCW04025K10FKEDC,"Resistor, 5.1k ohm 1% 1/16W",0402,SMD,
8,R3,1,Vishay,CRCW040251K0FKEDC,"Resistor, 51k ohm 1% 1/16W",0402,SMD,
9,R4,1,Panasonic,ERA-2APB512X,"Resistor, 5.1k ohm 0.1% 1/16W",0402,SMD,
10,R5,1,Panasonic,ERA-2APB153X,"Resistor, 15k ohm 0.1% 1/16W",0402,SMD,
11,SW1,1,Alps Alpine,SKRPACE010,Tactile Switch 4.2x3.2x2.5mm 260gf,4pos,SMD,
12,U1,1,Texas Instruments,SN74AHC1G00DRLR,Single 2-Input Positive-NAND Gate,DRL0005A,SMD,
13,U2,1,Texas Instruments,REF3325AIRSER,Voltage Reference,RSE0008A,SMD,
14,U3,1,Microchip Technology,MCP6232T-E/MNY,Operational Amplifier,TDFN-2X3,SMD,

## EAGLE design Hardwares/MDBT53VDB_AddInBoard/pcb_rev1/ADDINBRD_V1.brd

Board: 2 copper layers, 25.0 x 40.0 mm, 22 parts (0 on the bottom side), 23 nets.

Parts:
BAT1: BAT-HLD-012-SMT
C1, C2: 0.1uF; C0402N
CN1: 51296-0894
CN2: IF_6PIN; HEADER_6PIN
CN3: IF_3PIN; HEADER_3PIN
CN4: IF_5PIN_H; HEADER_5PIN
CN5: IF_2PIN; HEADER_2PIN
D1: APHF1608LSEEQBDZGKC
D2: PMEG2005BELD,315; DFN1006D-2
Q1: BSS84AKQBZ; BSS84AKQB
R1, R4: 5.1k; R0402N
R2: 20k; R0402N
R3: 1.2k; R0402N
R5: 330; R0402N
R6, R7, R8: 10k; R0402N
R9: 100; R0402N
SW1: SKTADAE010
U1: RV-3028-C7; SON-8

Connections:
0V: BAT1.-, C1.2, C2.2, CN1.2, CN4.1, CN5.1, R8.1, SW1.2, SW1.4, U1.5
CLK: CN1.6, CN2.6
CS: CN1.8, CN2.4
D_C: CN1.4, CN2.2
LEDA: CN1.1, Q1.3
LED_B: CN3.3, R5.1
LED_CTRL: CN2.1, R1.1
LED_G: CN3.2, R4.1
LED_R: CN3.1, R3.1
MOSI: CN1.5, CN2.5
unnamed: Q1.1, R1.2, R2.1
unnamed: CN5.2, D2.1
unnamed: C2.1, R9.1, U1.6
unnamed: R8.2, U1.8
unnamed: D1.4, R4.2
unnamed: D1.2, R3.2
unnamed: D1.3, R5.2
RESET: CN1.3, CN2.3
RESET_NRF: CN4.3, SW1.1, SW1.3
TWI_SCL: CN4.5, R7.1, U1.3
TWI_SDA: CN4.4, R6.1, U1.4
VDD: C1.1, CN1.7, CN4.2, D1.1, Q1.2, R2.2, R6.2, R7.2, U1.7
VDD_BATT: BAT1.+@2, D2.2, R9.2

File Hardwares/MDBT53VDB_AddInBoard/pcb_rev1/bom/ADDINBRD_V1_BOM.csv:

,,,,,,,,
,,,ADDINBRD_V1 1PCS BOM  (Bill of Materials),,,,,
,,,,,,,,
,,,,,,,,
,,,,,,,,
Item #,*Ref Des,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package,Type,Your Instructions / Notes
1,BAT1,1,Linx Technologies,BAT-HLD-012-SMT,Coin Cell Battery Holder,,SMD,
2,C1,1,Taiyo Yuden,UMK105B7104KV-FR,0.1uF,"0402",SMD,
3,CN1,1,Molex,51296-0894,0.5mm-8pins FFC & FPC Connector,,SMD,
4,"D1, D2",2,Nexperia,"PMEG2005BELD,315",Schottky Rectifier,SOD882D,SMD,
5,D3,1,Kingbright,APHF1608LSEEQBDZGKC,1.6 x 0.8 mm Full-Color Surface Mount LED,"0603",SMD,
6,Q1,1,Nexperia,BSS84AKQBZ,P-Channel MOSFET,SOT8015,SMD,
7,R1,1,Vishay,CRCW04025K10FKEDC,"Resistor, 5.1k ohm 1% 1/16W","0402",SMD,
8,R2,1,Vishay,CRCW040220K0FKEDC,"Resistor, 20k ohm 1% 1/16W","0402",SMD,
9,"R3, R4",2,Vishay,CRCW04021K20FKEDC,"Resistor, 1.2k ohm 1% 1/16W","0402",SMD,
10,R5,1,Vishay,CRCW0402330RFKEDC,"Resistor, 330 ohm 1% 1/16W","0402",SMD,
11,"R6, R7, R8, R9",4,Vishay,CRCW040210K0JNEDC,"Resistor, 10k ohm 5% 1/16W","0402",SMD,
12,U1,1,Micro Crystal AG,RV-3028-C7 32.768kHz 1ppm TA QC,Real Time Clock 32.768kHz I2C Time Acc. 1ppm,SON-8,SMD,'RV-3028-C7 32.768kHz 1ppm TA QA' as alternative

## EAGLE design Hardwares/MDBT53SlimBoard/pcb_rev1/MDBT53BD_01.brd

Parts:
C1, C2: 04025A120F4T2A; C0402K
C3, C4: C1608X7S1A475M080AC; C0603N
U1: MDBT53
X1: NX3215SA-32.768K-STD-MUA-9; NX3215

Connections:
0V: C1.2, C2.2, C3.2, C4.2, U1.1 (GND), U1.24 (GND), U1.42 (GND), U1.61 (GND); also elsewhere on the board
D_N: U1.48 (D-); also elsewhere on the board
D_P: U1.46 (D+); also elsewhere on the board
LED1: U1.60 (P0.28/AIN7); also elsewhere on the board
LED2: U1.65 (P0.29); also elsewhere on the board
LED3: U1.57 (P0.30); also elsewhere on the board
LED4: U1.56 (P0.31); also elsewhere on the board
LED_CTRL: U1.64 (P1.09); also elsewhere on the board
MAIN_SW: U1.62 (P0.23); also elsewhere on the board
P1_07: U1.63 (P1.07); also elsewhere on the board
P1_08: U1.3 (P1.08); also elsewhere on the board
RESET: U1.6 (RESET); also elsewhere on the board
SUB_SW: U1.8 (P0.24); also elsewhere on the board
SWDCLK: U1.2 (SWDCLK); also elsewhere on the board
SWDIO: U1.4 (SWDIO); also elsewhere on the board
TFT_CLK: U1.47 (P1.15); also elsewhere on the board
TFT_CS: U1.53 (P1.12); also elsewhere on the board
TFT_D_C: U1.55 (P1.11); also elsewhere on the board
TFT_MOSI: U1.51 (P1.13); also elsewhere on the board
TFT_RESET: U1.59 (P1.10); also elsewhere on the board
TWI_SCL: U1.31 (P1.03/TWI); also elsewhere on the board
TWI_SDA: U1.33 (P1.02/TWI); also elsewhere on the board
TXD: U1.13 (P0.20); also elsewhere on the board
VBUS_NRF: C4.1, U1.44 (VBUS); also elsewhere on the board
VDD_NRF: C3.1, U1.38 (VDD), U1.41 (VDDH); also elsewhere on the board
XL1: C1.1, U1.34 (P0.00/XL1), X1.1
XL2: C2.1, U1.36 (P0.01/XL2), X1.2

Notes on the sheet:
MDBT53 Slim Board
(rev1)
MDBT53 evaluation board
モジュール部
32.768kHzクリスタル
バイパスコンデンサー

Parts:
CN2, CN3, CN4: IF_6PIN; HEADER_6PIN
D1: APTD1608LSECK/J4-PF; APTD1608
D2: APHD1608LSURCK; APTD1608
D3: APTD1608LZGCK; APTD1608
D4: APTD1608LVBC/D; APTD1608
R1, R2: CRCW04021K20FKEDC; R0402N
R3: CRCW04021K50FKEDC; R0402N
R4: CRCW0402390RFKEDC; R0402N

Connections:
0V: CN2.1, CN4.1; also elsewhere on the board
LED1: R1.1; also elsewhere on the board
LED2: R2.1; also elsewhere on the board
LED3: R3.1; also elsewhere on the board
LED4: R4.1; also elsewhere on the board
LED_CTRL: CN3.1; also elsewhere on the board
unnamed: D1.C, R1.2
unnamed: D2.C, R2.2
unnamed: D3.C, R3.2
unnamed: D4.C, R4.2
P1_07: CN4.2; also elsewhere on the board
P1_08: CN4.3; also elsewhere on the board
RESET: CN2.5; also elsewhere on the board
SWDCLK: CN2.4; also elsewhere on the board
SWDIO: CN2.3; also elsewhere on the board
TFT_CLK: CN3.6; also elsewhere on the board
TFT_CS: CN3.4; also elsewhere on the board
TFT_D_C: CN3.2; also elsewhere on the board
TFT_MOSI: CN3.5; also elsewhere on the board
TFT_RESET: CN3.3; also elsewhere on the board
TWI_SCL: CN4.5; also elsewhere on the board
TWI_SDA: CN4.4; also elsewhere on the board
TXD: CN2.6; also elsewhere on the board
VDD_NRF: CN2.2, CN4.6, D1.A, D2.A, D3.A, D4.A; also elsewhere on the board

Notes on the sheet:
MDBT53 Slim Board
(rev1)
MDBT53 evaluation board
LED部
SWDインターフェース部
LED（黄色）
LED（赤色）
LED（緑色）
LED（青色）
変換基板インターフェース部
ピン対応 GND --> 1 P1.07 --> 2 P1.08 --> 3 SDA --> 4 SCL --> 5 VDD --> 6
RTCC回路接続用 汎用I/O接続ポート
TFTモジュール接続用 汎用I/O接続ポート
ピン対応 P1.09 --> 1 P1.10 --> 2 P1.11 --> 3 P1.12 --> 4 P1.13 --> 5 P1.15 --> 6

Parts:
BAT1: BAT-HLD-012-SMT
C5: C0402C103K5RAC7411; C0402N
C6, C7: UMK105B7104KV-FR; C0402N
C8: C0603C106M8PACTU; C0603N
C9, C10: TMR107B7105KA-T; C0603N
CN1: USB4105-GF-A
D5: PRTR5V0U2X; SOT143B
D6, D7: PMEG2005AEA,115; SOD323-W
FB1, FB2, FB3, FB4: BLM15AG121SN1D; C0402N
R5, R6: CRCW04025K10FKED; R0402N
R7: CRCW04022R20FKEDC; R0402N
R8, R9: CRCW04020000Z0EDC; R0402N
SW1, SW2: SKRPACE010
U2: XC6206P302MR-G; SOT23

Connections:
0V: BAT1.-, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D5.1 (GND), FB3.2, FB4.2, R5.2, R6.2, SW1.3 (S), SW1.4 (S1), SW2.3 (S), SW2.4 (S1), U2.1 (VSS); also elsewhere on the board
D_N: R9.2; also elsewhere on the board
D_P: R8.2; also elsewhere on the board
MAIN_SW: SW1.1, SW1.2 (P1); also elsewhere on the board
unnamed: CN1.B5 (CC2), R6.1
unnamed: C10.1, D6.A, U2.2 (VOUT)
unnamed: BAT1.+@2 (+), D7.A
unnamed: CN1.A5 (CC1), R5.1
unnamed: CN1.FG1, CN1.FG2, CN1.FG3, CN1.FG4, FB4.1
unnamed: CN1.A1 (GND1), CN1.B1 (GND2), FB3.1
unnamed: C6.1, FB2.2, R7.1
unnamed: CN1.A7 (D_N1), CN1.B7 (D_N2), D5.2 (I/O_1), R9.1
unnamed: C5.1, C7.1, C8.1, CN1.A4 (VBUS1), CN1.B4 (VBUS2), D5.4 (VCC), FB1.1, FB2.1
unnamed: CN1.A6 (D_P1), CN1.B6 (D_P2), D5.3 (I/O_2), R8.1
SUB_SW: SW2.1, SW2.2 (P1); also elsewhere on the board
VBUS_LDO: C9.1, FB1.2, U2.3 (VIN)
VBUS_NRF: R7.2; also elsewhere on the board
VDD_NRF: D6.C, D7.C; also elsewhere on the board

Notes on the sheet:
MDBT53 Slim Board
(rev1)
MDBT53 evaluation board
USBインターフェース部
電源供給部
ユーザーボタン

Board: 2 copper layers, 40 parts (0 on the bottom side), 42 nets, no tracks yet.

## Code that names these connections

File nRF5340FW/square_devices_app/app/app_board.c:

/* 
 * File:   app_board.c
 * Author: makmorit
 *
 * Created on 2023/05/04, 18:06
 */
#include <stdio.h>
#include <string.h>
#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/sys/time_units.h>

#include "app_board.h"
#include "app_event.h"
#include "app_event_define.h"

// ログ出力制御
#include <zephyr/logging/log.h>
LOG_MODULE_REGISTER(app_board);

#define LOG_BUTTON_INITIALIZED  false
#define LOG_BUTTON_PRESSED      false

//
// 共通処理
//
uint32_t app_board_kernel_uptime_ms_get(void)
{
    // システム起動後の通算ミリ秒数を取得
    return k_cyc_to_ms_floor32(k_cycle_get_32());
}

bool app_board_get_version_info_csv(uint8_t *info_csv_data, size_t *info_csv_size)
{
    // 格納領域を初期化
    memset(info_csv_data, 0, *info_csv_size);

    // 各項目をCSV化し、引数のバッファに格納
    sprintf((char *)info_csv_data,
        "DEVICE_NAME=\"%s\",FW_REV=\"%s\",HW_REV=\"%s\",FW_BUILD=\"%d\"", 
            CONFIG_BT_DIS_MODEL, CONFIG_BT_DIS_FW_REV_STR, CONFIG_BT_DIS_HW_REV_STR, CONFIG_APP_FW_BUILD);

    *info_csv_size = strlen((char *)info_csv_data);
    LOG_DBG("Application version info csv created (%d bytes)", *info_csv_size);
    return true;
}

//
// ボタン関連
//
static const struct gpio_dt_spec button_0 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(sw0), gpios, {0});
static const struct gpio_dt_spec button_1 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(sw1), gpios, {0});
static struct gpio_callback button_cb_0, button_cb_1;
static bool button_press_enabled = false;

void app_board_button_press_enable(bool b)
{
    button_press_enabled = b;
}

static bool button_pressed(const struct device *dev, gpio_pin_t pin, int *status_pressed, uint32_t *time_pressed)
{
    if (button_press_enabled == false) {
        return false;
    }

    // ボタン検知状態を取得
    int status_now = gpio_pin_get(dev, pin);

    // ボタン検知時刻を取得
    uint32_t time_now = app_board_kernel_uptime_ms_get();

    // ２回連続検知の場合は無視
    if (status_now == *status_pressed) {
#if LOG_BUTTON_PRESSED
        LOG_DBG("%s (invalid)", status_now ? "pushed" : "released");
#endif
        return false;
    }
    *status_pressed = status_now;

    // 短時間の間に検知された場合は無視
    uint32_t elapsed = time_now - *time_pressed;
    if (elapsed < 50) {
#if LOG_BUTTON_PRESSED
        LOG_DBG("%s (ignored)", status_now ? "pushed" : "released");
#endif
        return false;
    }
    *time_pressed = time_now;

#if LOG_BUTTON_PRESSED
    LOG_DBG("%s (elapsed %u msec)", status_now ? "pushed" : "released", elapsed);
#endif
    return true;
}

static void button_pressed_0(const struct device *dev, struct gpio_callback *cb, uint32_t pins)
{
    // ボタン検知状態・検知時刻を保持
    static int status_pressed = 0;
    static uint32_t time_pressed = 0;

    // ボタン検知処理
    if (button_pressed(dev, button_0.pin, &status_pressed, &time_pressed) == false) {
        return;
    }

    // ボタン検知イベントを業務処理スレッドに引き渡す
    app_event_notify(status_pressed ? APEVT_BUTTON_PUSHED : APEVT_BUTTON_RELEASED);
}

static void button_pressed_1(const struct device *dev, struct gpio_callback *cb, uint32_t pins)
{
    // ボタン検知状態・検知時刻を保持
    static int status_pressed = 0;
    static uint32_t time_pressed = 0;

    // ボタン検知処理
    if (button_pressed(dev, button_1.pin, &status_pressed, &time_pressed) == false) {
        return;
    }

    // ボタン検知イベントを業務処理スレッドに引き渡す
    app_event_notify(status_pressed ? APEVT_BUTTON_1_PUSHED : APEVT_BUTTON_1_RELEASED);
}

static bool initialize_button(const struct gpio_dt_spec *button, struct gpio_callback *callback, gpio_callback_handler_t handler)
{
    if (device_is_ready(button->port) == false) {
        LOG_ERR("Error: didn't find %s device", button->port->name);
        return false;
    }

    int ret = gpio_pin_configure_dt(button, GPIO_INPUT);
    if (ret != 0) {
        LOG_ERR("Error %d: failed to configure %s pin %d", ret, button->port->name, button->pin);
        return false;
    }

    ret = gpio_pin_interrupt_configure_dt(button, GPIO_INT_EDGE_BOTH);
    if (ret != 0) {
        LOG_ERR("Error %d: failed to configure interrupt on %s pin %d", ret, button->port->name, button->pin);
        return false;
    }

    // ボタン押下時のコールバックを設定
    gpio_init_callback(callback, handler, BIT(button->pin));
    gpio_add_callback(button->port, callback);

    // ボタンの参照を戻す
#if LOG_BUTTON_INITIALIZED
    LOG_DBG("Set up button at %s pin %d", button->port->name, button->pin);
#endif
    return true;
}

//
// LED関連
//
static struct gpio_dt_spec m_led_0 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(led0), gpios, {0});
static struct gpio_dt_spec m_led_1 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(led1), gpios, {0});
static struct gpio_dt_spec m_led_2 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(led2), gpios, {0});
static struct gpio_dt_spec m_led_3 = GPIO_DT_SPEC_GET_OR(DT_ALIAS(led3), gpios, {0});

static bool initialize_led(struct gpio_dt_spec *led)
{
    if (device_is_ready(led->port) == false) {
        LOG_ERR("Didn't find LED device %s", led->port->name);
        return false;
    }

    int ret = gpio_pin_configure_dt(led, GPIO_OUTPUT);
    if (ret != 0) {
        LOG_ERR("Error %d: failed to configure LED device %s pin %d", ret, led->port->name, led->pin);
        return false;
    }

    // 最初は消灯しておく
    gpio_pin_set(led->port, led->pin, 0);

    // LED0の参照を戻す
#if LOG_BUTTON_INITIALIZED
    LOG_DBG("Set up LED at %s pin %d", name, pin);
#endif
    return true;
}

void app_board_initialize(void)
{
    // ボタンの初期化
    initialize_button(&button_0, &button_cb_0, button_pressed_0);
    initialize_button(&button_1, &button_cb_1, button_pressed_1);
    
    // LED0の初期化
    initialize_led(&m_led_0);
    initialize_led(&m_led_1);
    initialize_led(&m_led_2);
    initialize_led(&m_led_3);
}

void app_board_led_light(LED_COLOR led_color, bool led_on)
{
    // 業務で使用するLEDを点灯／消灯
    //   LED1=Yellow (Orange)
    //   LED2=Red
    //   LED3=Green
    //   LED4=Blue
    switch (led_color) {
        case LED_COLOR_YELLOW:
            gpio_pin_set(m_led_0.port, m_led_0.pin, led_on ? 1 : 0);
            break;
        case LED_COLOR_RED:
            gpio_pin_set(m_led_1.port, m_led_1.pin, led_on ? 1 : 0);
            break;
        case LED_COLOR_GREEN:
            gpio_pin_set(m_led_2.port, m_led_2.pin, led_on ? 1 : 0);
            break;
        case LED_COLOR_BLUE:
            gpio_pin_set(m_led_3.port, m_led_3.pin, led_on ? 1 : 0);
            break;
        default:
            break;
    }
}

void app_board_led_test(void)
{
    static int status = 0;
    switch (++status) {
        case 1:
            app_board_led_light(LED_COLOR_RED,   true);
            break;
        case 2:
            app_board_led_light(LED_COLOR_RED,   false);
            app_board_led_light(LED_COLOR_GREEN, true);
            break;
        case 3:
            app_board_led_light(LED_COLOR_GREEN, false);
            app_board_led_light(LED_COLOR_BLUE,  true);
            break;
        default:
            app_board_led_light(LED_COLOR_RED,   false);
            app_board_led_light(LED_COLOR_GREEN, false);
            app_board_led_light(LED_COLOR_BLUE,  false);
            status = 0;
            break;
    }
}

//
// ディープスリープ（system off）状態に遷移
// --> ボタン押下でシステムが再始動
//
#include <hal/nrf_gpio.h>
#include <zephyr/sys/poweroff.h>

static void system_off_work_handler(struct k_work *work);
static K_WORK_DELAYABLE_DEFINE(system_off_work, system_off_work_handler);

void app_board_prepare_for_deep_sleep(void)
{
    // ポート番号（Port 0=0x00, Port 1=0x20）をピン番号に付加
#if LOG_BUTTON_INITIALIZED
    printk("Set up button for deep sleep at %s pin %d\n\r", button_0.port->name, button_0.pin);
#endif
    uint32_t sw0_pin_number = button_0.pin;
    if (strcmp(button_0.port->name, "gpio@842800") == 0) {
        sw0_pin_number |= (0x1 << 5);
    }

    // Configure to generate PORT event (wakeup) on button-1 press.
    nrf_gpio_cfg_input(sw0_pin_number, NRF_GPIO_PIN_PULLUP);
    nrf_gpio_cfg_sense_set(sw0_pin_number, NRF_GPIO_PIN_SENSE_LOW);

    printk("Entering system off; press BUTTON to restart... \n\n\r");
    k_work_schedule(&system_off_work, K_MSEC(2000));
}

static void system_off_work_handler(struct k_work *work)
{
    sys_poweroff();
}

//
// システムを再始動させる
// （RESETボタン押下と等価の処理）
//
void app_board_prepare_for_system_reset(void)
{
    printk("System will restart... \n\n\r");
    NVIC_SystemReset();
}

## Commit log (part)

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2024-01-22 リファクタリング
    ・不要な import を削除
    ・エラーメッセージを内部保持させないよう修正
2024-01-22 機能実装
    ・反映要求処理を本格実装
2024-01-25 機能実装
    ・リセット要求処理の仮実装
2024-01-25 機能実装
    ・リセット要求コマンドの実装
2024-01-25 機能実装
    ・リセット要求-->反映待ち処理を本格実装
2024-01-25 機能実装
    ・ファームウェア更新イメージのバージョン情報を保持させるよう修正
2024-01-25 機能実装
    ・転送後のバージョンチェック処理を本格実装
2024-01-25 機能実装
    ・ログ出力フラグ設定時のみ、ログ出力されるよう修正
2024-01-25 機能実装
    ・イメージ転送処理時は、ログ出力が行われないよう設定
2024-01-25 リファクタリング
    ・モジュールヘッダーの`#define`を、共通定義用ヘッダーファイルに移動
2024-01-26 事前準備
    ・ビルド番号を更新
2024-01-26 機能実装
    ・現在時刻参照の機能クラスを新設
2024-01-26 機能実装
    ・現在時刻参照機能のメニューを開通
2024-01-26 機能実装
    ・`DeviceTimestampShow`に、`DeviceTimestampDelegate`を実装
2024-01-26 機能実装
    ・接続／切断処理を実装
2024-01-26 機能実装
    ・現在時刻参照コマンド実行の実装
2024-01-29 機能実装
    ・レスポンスデータから現在時刻を抽出する処理の実装
2024-01-29 機能実装
    ・現在時刻文字列を生成する処理の実装
2024-01-29 画面サイズの拡張
    ・ホーム画面（再外枠）の拡張
2024-01-29 画面サイズの拡張
    ・ホーム画面表示部（`ToolMainView.xib`）の大きさを、再外枠（`MainWindow.xib`）に合わせるよう修正
2024-01-29 画面サイズの拡張
    ・左側メニュー部の高さを、ホーム画面の高さに合わせるよう修正
    （幅の変更はありません）
2024-01-29 リファクタリング
    ・画面描画位置・領域を動的指定させるよう修正
2024-01-29 リファクタリング
    ・サブビュー描画位置・領域の設定情報を、`ToolMainView`で再計算の上、サブビューに引き渡すよう修正
2024-01-29 画面サイズの拡張
    ・右側業務画面部の高さを、ホーム画面の幅・高さに合わせるよう修正
2024-01-29 リファクタリング
    ・エラーメッセージを、プロパティーではなくデリゲート引数で引き渡すよう修正
2024-01-29 リファクタリング
    ・エラーが発生した場合、専用デリゲートにより、エラーメッセージとともに通知を受けるよう修正
2024-02-01 機能実装
    ・現在時刻設定機能のメニューを開通
2024-02-01 機能実装
    ・`DeviceTimestampDelegate`を実装
2024-02-01 機能実装
    ・処理前に確認ダイアログを開くよう実装
2024-02-01 機能実装
    ・現在時刻設定コマンドを実装
2024-02-01 機能実装
    ・現在時刻設定処理の実装
2024-02-01 機能実装
    ・PINGテストの機能クラスを新設
2024-02-01 機能実装
    ・PINGテスト機能のメニューを開通
2024-02-01 機能実装
    ・PINGテスト用のコマンドクラスを新設
2024-02-01 機能実装
    ・機能クラスに`PingTestQueryDelegate`を実装
2024-02-02 機能実装
    ・リクエスト／レスポンス用のセレクターを仮実装
2024-02-02 機能実装
    ・PINGデータをコマンドクラス内部でも保持させるよう修正
2024-02-02 機能実装
    ・BLEサービス接続／切断処理の実装
2024-02-02 機能実装
    ・PINGテストコマンド実行処理を実装
2024-02-02 機能実装
    ・終了処理の実装
2024-02-02 機能実装
    ・PINGバイトの一致チェックを追加
2024-02-02 リファクタリング
    ・以前の仮実装を一旦削除
2024-02-02 機能実装
    ・Flash ROM情報参照の機能クラスを新設
2024-02-05 機能実装
    ・Flash ROM情報参照のコマンドクラスを新設
2024-02-05 機能実装
    ・コマンドクラスに`BLETransportDelegate`を実装
2024-02-05 機能実装
    ・機能クラスに`DeviceStorageDelegate`を実装
2024-02-05 機能実装
    ・Flash ROM情報照会コマンドを実装
2024-02-05 機能実装
    ・コマンド実行結果をFlash ROM情報に抽出する処理の実装
2024-02-05 リファクタリング
    ・コメントを修正
2024-02-05 機能実装
    ・終了処理を実装
2024-02-05 機能実装
    ・機能クラスに`FWVersionDelegate`を実装
2024-02-05 機能実装
    ・バージョン参照処理実行の仮実装
2024-02-05 リファクタリング
    ・「ツールのバージョン」画面を、画面拡張に合わせるよう修正
    （#46 での対応漏れ）
2024-02-05 リファクタリング
    ・Copyrightを更新
2024-02-05 Update LICENSE
2024-02-05 リファクタリング
    ・不要なライブラリーを削除
2024-02-11 リファクタリング
    ・不要ファイルを削除
2024-02-11 機能修正
    ・BLE U2Fサービスにおいて、リクエスト〜レスポンス間で発生した接続タイムアウトを検知できるよう修正
    （タイムアウトエラーとして上位クラスに通知できるようにしています。）
2024-02-11 インストーラー作成
    ・インストーラー作成用のプロパティーリストを設置
2024-02-11 インストーラー作成
    ・Intel mac用のインストーラーを作成
2024-02-12 ドキュメントを更新
    ・ARM GCCインストール手順書を作成
2024-02-12 ドキュメントを更新
    ・nRF Connect SDKインストール手順書に追記
2024-02-12 ドキュメントを更新
    ・不要となった手順書を削除
2024-02-15 ドキュメントを更新
    ・nRF5340 DK初期化手順書を作成
2024-02-15 ドキュメントを更新
    ・nRF5340 DK初期化手順書に追記
2024-02-15 ドキュメントを更新
    ・nRF Connect SDK動作確認手順書に追記
2024-02-15 バージョン移行
    ・オリジナルソースコード`main.c`のバージョン差異を吸収
    （nRF5340ファームウェアのベースとなった`zephyr/sample/bluetooth/peripheral_dis`の修正に追従）
2024-02-16 バージョン移行
    ・`SYS_INIT`用関数の引数を変更
2024-02-16 バージョン移行
    ・SMPサービスで不要となったヘッダー／関数を削除
    ・ヘッダーファイルのパスを修正
2024-02-16 バージョン移行
    ・不要となった属性を削除
2024-02-16 バージョン移行
    ・廃止されてしまったファイルを、Make対象から削除
2024-02-16 バージョン移行
    ・ビルドに使用するツールチェインをZephyr SDKに変更
    ・ビルドに使用するnCSのバージョンを2.2.0 --> 2.5.2に変更
2024-02-16 リファクタリング
    ・現状使用／参照されていない機能／ライブラリーに関する定義体を削除
2024-02-16 リファクタリング
    ・現状使用／参照されていないUSB関連モジュールを削除
2024-02-16 リファクタリング
    ・使用していないUSB機能をバイパス
2024-02-16 リファクタリング
    ・使用していない暗号化関連機能をバイパス
2024-02-16 バージョン移行
    ・新バージョンで利用不可となった`pm_state_force`をバイパス
    （ただし、代替えの関数を調査する必要があります。）
2024-02-19 バージョン移行
    ・関数`sys_poweroff`が利用できるよう修正
2024-02-19 バージョン移行
    ・config warning が表示されないよう修正
2024-02-19 バージョン移行
    ・BLE SMPサービスのバージョンアップにより、不要となったコードを削除
2024-02-19 リファクタリング
    ・不要となった定義／関数等を削除
2024-02-19 リファクタリング
    ・ビルド番号を更新
2024-02-22 機能修正
    ・`printf`を`log_debug`に変更し、エラー発生時にログファイル出力されるよう修正
2024-02-22 機能修正
    ・`printf`を`log_debug`に変更し、エラー発生時にログファイル出力されるよう修正
    （Commit 6292adc の横展開）
2024-02-22 バージョン移行
    ・BLE SMPサービスの仕様変更に追従
    （イメージ転送処理のレスポンスチェック処理を修正）
2024-02-22 バージョン移行
    ・バージョン移行済みのファームウェア更新イメージファイルを同梱
2024-02-23 リファクタリング
    ・ペアリング情報の個別削除処理を、一括削除処理と同じ関数`bt_unpair`を使用して実行させるよう修正
2024-02-23 ファームウェア更新イメージの差替え
    ・デスクトップツールに同梱している、ファームウェア更新イメージファイルを差替え
2024-02-23 ファームウェア更新イメージの差替え
    ・プロジェクト構成記述を修正
2024-02-26 バージョン移行
    ・BLE SMPサービスの仕様変更に追従
    （イメージ転送処理のレスポンスチェック処理を修正。Commit 23ca182 の横展開）
2024-02-29 バージョン更改（0.1.0、Windows版デスクトップツール）
    ・同梱ファームウェアを更新（Version 0.0.4、PCA10095_01）
    ・ファームウェア更新（nRF Connect SDK v2.5.2移行）にともなうファームウェア更新処理の小修正
2024-02-29 ドキュメントを更新
    ・ポータルページを更新
2024-02-29 ドキュメントを更新
    ・誤字訂正
2024-02-29 リファクタリング
    ・マークダウン格納位置を変更
2024-02-29 ドキュメントを更新
    ・インストール手順書を作成
2024-03-01 ドキュメントを更新
    ・ログファイル参照手順書を作成
2024-03-04 ドキュメントを更新
    ・現在時刻参照／設定手順書を作成
2024-03-07 ドキュメントを更新
    ・ハードウェアに関するドキュメントを追加
2024-03-08 ドキュメントを更新
    ・重複記述を削除
    ・誤字訂正
2024-03-08 ドキュメントを更新
    ・超小型TFTディスプレイに関する記述を追加
2024-03-14 ドキュメントを更新
    ・ペアリング手順書を追加
2024-03-14 ドキュメントを更新
    ・ペアリング手順書のリンクを追加
2024-03-14 ドキュメントを更新
    ・基板ポータルページに画像を追加
2024-03-15 ドキュメントを更新
    ・ペアリング手順書用の画面コピーを追加
2024-03-18 ドキュメントを更新
    ・PINGテスト手順を追記
2024-03-21 リファクタリング
    ・非推奨となったAPIを置換
2024-03-21 リファクタリング
    ・不要となった機能を削除
2024-03-21 リファクタリング
    ・不要となったファイルを削除
2024-03-22 ドキュメントを更新
    ・不要機能を削除
2024-03-25 ドキュメントを更新
    ・ファームウェア更新手順書用の画面コピーを追加
2024-03-28 ドキュメントを更新
    ・ファームウェア更新手順書を追加
2024-03-28 ドキュメントを更新
    ・ファームウェア更新手順書のリンクを追加
2024-03-29 リファクタリング
    ・ベンダー向けツール関連のコードを削除
2024-03-29 リファクタリング
    ・ベンダー向けツール関連のリソースを削除
2024-03-29 バージョン更改（0.1.0、macOS版デスクトップツール）
    ・同梱ファームウェアを更新（Version 0.0.4、PCA10095_01）
    ・ファームウェア更新（nRF Connect SDK v2.5.2移行）にともなうファームウェア更新処理の小修正
2024-03-29 ドキュメントを更新
    ・不要機能に関する記述を削除
2024-03-29 ドキュメントを更新
    ・手順書用の画像を追加
2024-04-01 ドキュメントを更新
    ・現在時刻参照／設定手順書用の画像を追加
2024-04-01 ドキュメントを更新
    ・現在時刻参照／設定手順書を追加
2024-04-01 ドキュメントを更新
    ・リンクが間違っているので修正
2024-04-01 ドキュメントを更新
    ・インストール手順書用の画像を追加
2024-04-01 ドキュメントを更新
    ・ペアリング手順書用の画像を追加
2024-04-04 バージョン更改（0.1.0、Windows版デスクトップツール）
    ・同梱ファームウェアを更新（Version 0.0.4、PCA10095_01）
    ・ファームウェア更新（nRF Connect SDK v2.5.2移行）にともなうファームウェア更新処理の小修正
    ・リファクタリングの実施（不要機能の整理）
2024-04-05 ドキュメントを更新
    ・ポータルページのレイアウト変更
2024-04-05 ドキュメントを更新
    ・nRF5340ファームウェアのポータルを新設
2024-04-11 ドキュメントを更新
    ・ライブラリー「Tiny TFT Library」に関する記述を追加
2024-04-12 ドキュメントを更新
    ・リンクを追加
2024-04-12 ドキュメントを更新
    ・文言を修正
    ・最終更新日を修正
2024-04-19 リファクタリング
    ・ボタン位置を、右端からの相対指定に変更
2024-04-19 機能修正
    ・ツールの画面幅を、機能画面の幅（500px）に合わせる
2024-04-19 機能修正
    ・ホームメニューにおけるメニュー領域を表示／非表示化するための関数を新設
2024-04-19 機能修正
    ・メニュー領域の活性／不活性制御を、表示／非表示制御で置換
2024-04-19 機能修正
    ・機能画面表示に合わせ、メイン画面の左側のViewと、サイドメニューのViewを同時に表示／非表示制御させるよう修正
2024-04-19 機能修正
    ・リビジョンを更新
2024-04-22 ドキュメントを更新
    ・記述内容を最新に修正
2024-04-22 ドキュメントを更新
    ・記述内容を更新
2024-04-26 機能修正
    ・サイドメニューの表示／非表示制御を、Viewの外側で実行できるよう修正
2024-04-29 リファクタリング
    ・サイドメニュークラスを新設
    （サイドメニューのView参照をメイン画面クラスから分離させるための措置）
2024-04-29 リファクタリング
    ・メイン画面〜サイドメニュー間の制御を、クラス`SideMenu`経由で行うよう修正
2024-05-02 機能修正
    ・フレームサイズを修正
    （Viewの左右間境界が不要となったための措置）
2024-05-03 機能修正
    ・業務処理画面を画面領域いっぱいに表示させるよう修正
2024-05-03 リファクタリング
    ・メイン画面クラスを新設
    （メイン画面＝スタックビューのView参照をアプリケーション・デリゲートから分離させるための措置）
2024-05-03 リファクタリング
    ・参照名称を変更
2024-05-03 リファクタリング
    ・モジュールのフォルダー構成を変更
2024-05-03 リファクタリング
    ・クラス等の名称を、処理内容の実態に即した名称に変更
2024-05-03 リファクタリング
    ・xibの名称を変更
2024-05-03 リファクタリング
    ・モジュールのファイル名称を変更
    ・プロジェクト内の配置を見直し
2024-05-03 ドキュメントを更新
    ・画像表示サイズを修正
2024-05-10 ドキュメントを更新
    ・評価基板に関するポータルを追加
2024-06-13 ドキュメントを更新
    ・westツール更新ログを最新版に更新
2024-06-13 ドキュメントを更新
    ・nCSのチェックアウトログを最新版に更新
2024-06-13 ドキュメントを更新
    ・Zephyr SDK導入ログを最新版に更新
2024-06-13 ドキュメントを更新
    ・nRF Connect SDKインストール手順書を最新版に更新
2024-06-13 ドキュメントを更新
    ・サンプルアプリのビルド用スクリプトを最新版に更新
2024-06-13 ドキュメントを更新
    ・サンプルアプリのビルドログを最新版に更新
2024-06-13 ドキュメントを更新
    ・サンプルアプリの書き込みログを最新版に更新
2024-06-13 バージョン移行
    ・ビルドに使用するZephyr SDKのバージョンを0.16.1 --> 0.16.5に変更
    ・ビルドに使用するnCSのバージョンを2.5.2 --> 2.6.1に変更
2024-06-17 ドキュメントを更新
    ・`MDBT53V-DB-40`を使用し、サンプルアプリ`Peripheral UART`の動作確認を行うための手順書を記述
    （内容は、作成途上です。）
2024-06-20 ドキュメントを更新
    ・サンプルアプリ動作確認手順書を修正
2024-06-21 ドキュメントを更新
    ・サンプルアプリ動作確認手順書用の画像を追加
2024-06-21 ドキュメントを更新
    ・サンプルアプリ動作確認時のスクリプト実行ログを追加
2024-06-27 リファクタリング
    ・ファイル名を変更
2024-06-27 リファクタリング
    ・定義ファイルを一本化
2024-06-27 リファクタリング
    ・ビルド対象をスクリプトに固定コーディングしないよう修正
    （ビルド対象の環境変数を、スクリプト実行前に設定しておく前提とするよう変更）
    ・Commit 7eaa3dd / 4e89859 の変更に追従
2024-06-27 MDBT53V-DB用ファームウェアの制作
    ・MDBT53V-DB用のデバイステーブルを作成
2024-06-27 MDBT53V-DB用ファームウェアの制作
    ・ボード専用のConfigを作成
2024-06-27 リファクタリング
    ・コメントを強化
2024-06-27 バグ修正
    ・MDBT53V-DBがスリープ状態に遷移後、ボタン１を押下してもスリープから復帰しない不具合を解消
    （デバイス名称判定ロジック不良による障害。`port1`を表すデバイス名称を正しく判定するよう修正）
2024-06-28 ドキュメントを更新
    ・nRF5340ファームウェアのポータルを修正
2024-06-28 ドキュメントを更新
    ・nRF5340開発ボードについてのドキュメントを追加
2024-06-28 ドキュメントを更新
    ・ピン割り当ての変更
2024-07-01 疎通確認
    ・RTCC用シリアルバス（`i2c1`）を有効化
2024-07-01 疎通確認
    ・RTCC（リアルタイムクロックカレンダー）機能を有効化
2024-07-01 疎通確認
    ・TFT用シリアルバス（`spi4`）を有効化
2024-07-01 疎通確認
    ・TFTディスプレイ機能用のピン割当設定を追加
2024-07-01 疎通確認
    ・TFTディスプレイ機能を有効化
2024-07-01 ドキュメントを更新
    ・ピン割り当て情報を正しく修正
2024-07-04 機能修正
    ・LED動作テスト用関数の新設
2024-07-04 機能修正
    ・LED動作テスト用関数の動作可否についての定義体を新設
2024-07-04 機能修正
    ・ボタン２を押すごとに、３色LEDが色を変えて点灯する動作テストの実装
    （定義体`CONFIG_APP_SETTINGS_BUTTON2_LED_TEST`で有効化／無効化できます）
2024-07-04 機能修正
    ・ボタン２によるLED動作テストを、既定「Off」とするよう修正
2024-07-05 部品表
    ・初版
    （後日修正する可能性があります。）
2024-07-08 回路図を修正
    ・ERCを通す
    ・ボタン乾電池とVDDの間に、2pinジャンパーヘッダーを設置
2024-07-08 回路図を出力
2024-07-11 回路図を修正
    ・定数を修正
2024-07-11 回路図を修正
    ・部品番号を修正
2024-07-12 回路図を修正
    ・リセット回路の追加
2024-07-15 ドキュメントを更新
    ・MDBT53V-DB用拡張基板のポータルを新設
2024-07-15 ドキュメントを更新
    ・ハードウェアポータルの記述内容を更新
2024-07-18 レイアウトを作成
    ・初版
    （おおまかな位置決め）
2024-07-22 回路図を修正
    ・ピン割り当てが逆転していたので修正
2024-07-22 回路図を再出力
2024-07-22 レイアウトを修正
    ・部品、シルク位置を修正
2024-07-25 レイアウトを修正
    ・３色LED、リセットボタンの配線
2024-07-25 レイアウトを修正
    ・TFTモジュール周りの配線
2024-07-25 レイアウト図を出力
2024-07-25 レイアウトを修正
    ・レイアウト図に`dimension`を追加
2024-07-26 部品表を修正
    ・回路修正内容を反映
2024-07-26 基板製作データの出力
    ・gerber／centroidの出力
2024-07-29 回路図を追加
    ・ひな型を作成
2024-07-29 回路図を修正
    ・表題を追加
2024-08-01 レイアウトを修正
    ・リセッタブルヒューズを配置
2024-08-01 レイアウトを修正
    ・SBD（極性逆転阻止用）を配置
2024-08-02 レイアウトを修正
    ・MOSFETを配置
2024-08-05 レイアウトを修正
    ・ロジックICを配置
2024-08-05 レイアウトを修正
    ・パッド間隔が0.22mm以上になるよう、パッドの広さを調整
2024-08-08 Update ADDINBRD2_V1.sch
    ・BJTを配置
2024-08-08 回路図を修正
    ・電源投入／遮断回路の配線
    ・抵抗器２点を追加
2024-08-09 回路図を修正
    ・ベース抵抗の定数を変更
    ・コメントを追加
2024-08-09 回路図を修正
    ・基準電圧ICを配置
2024-08-12 回路図を修正
    ・基準電圧回路にバイパスコンデンサーを配置
2024-08-12 回路図を修正
    ・分圧回路を追加
2024-08-12 レイアウトを修正
    ・部品ライブラリーの一部を入れ替え
2024-08-12 回路図を修正
    ・２素子オペアンプの配置
2024-08-12 回路図を修正
    ・オペアンプのシンボル図を変更
2024-08-12 回路図を修正
    ・オペアンプ電源用のバイパスコンデンサーを配置
2024-08-15 回路図を修正
    ・オペアンプ周りの配線
2024-08-16 回路図を修正
    ・電圧測定用の外部接続用端子を追加
2024-08-16 回路図を修正
    ・外部接続用端子を設置
2024-08-16 回路図を修正
    ・コメントを追加
2024-08-26 レイアウトを修正
    ・電源遮断回路の部品配置を修正
2024-08-26 レイアウトを修正
    ・シルクの出力位置を修正
2024-08-26 レイアウトを修正
    ・電源投入回路の部品配置を修正
2024-08-29 レイアウトを修正
    ・バイパスコンデンサーの位置を調整
2024-09-02 レイアウトを修正
    ・部品配置を変更
    ・シルク文言を修正
2024-09-02 レイアウトを修正
    ・ロジックIC周りを配線
2024-09-02 レイアウトを修正
    ・VBAT-->AVIN（設定ジャンパー）周りを配線
2024-09-06 レイアウトを修正
    ・測定電圧周りを配線
2024-09-06 レイアウトを修正
    ・バッファ周りを配線
2024-09-12 テスト準備
    ・Battery Service Profileを有効化するための設定
2024-09-12 テスト準備
    ・Battery Service Profileのテスト用定義を新設
2024-09-12 BAS実装の追加
    ・アドバタイズ対象サービスにBattery Service Profile を追加
2024-09-16 BAS実装の追加
    ・Battery Service Profileの実体を実装
2024-09-16 テスト準備
    ・Battery Service Profileテスト処理を実装
2024-09-16 部品表を作成
2024-09-16 基板製作データの出力
2024-09-19 テスト準備
    ・ADCテスト用定義を新設
2024-09-19 テスト準備
    ・ADC関連モジュールを新設
2024-09-19 設定変更
    ・ADC機能の利用可否設定を新設
2024-09-19 設定変更
    ・ADCを利用できるようにするための設定ファイルを追加
2024-09-19 設定変更
    ・ADC設定ファイル`adc.overlay`をビルド時に取り込むよう修正
2024-09-19 設定変更
    ・Zephyr ADC APIが利用できるようにするための設定項目を追加
